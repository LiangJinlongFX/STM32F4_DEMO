# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\BSP_USER\LED;..\CORE;..\Common;..\STM32f4_LIB\inc;..\SYSTEM;..\BSP_USER\SDIO_SD;..\FATFS\exfuns;..\FATFS\src;..\BSP_USER\MALLOC
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CORE
    ../CORE/: core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f40_41xxx.s
  group SYSTEM
    ../SYSTEM/: main.c stm32f4xx_it.c system_stm32f4xx.c
  group BSP_USER
    ../BSP_USER/LED/: led.c
    ../BSP_USER/SDIO_SD/: sdio_sdcard.c
    ../BSP_USER/MALLOC/: malloc.c
  group Common
    ../Common/: delay.c sys.c usart1.c
  group STM32F4_LIB
    ../STM32f4_LIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_syscfg.c stm32f4xx_dma.c stm32f4xx_sdio.c
  group FATFS
    ../FATFS/exfuns/: exfuns.c
    ../FATFS/src/: diskio.c ff.c
software components: CMSIS:CORE 4.3.0
